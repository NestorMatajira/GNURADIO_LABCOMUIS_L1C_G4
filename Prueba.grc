options:
  parameters:
    generate_options: qt_gui
    id: Prueba
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Modulos_L1C_ParteenteraL1C_0
  id: Modulos_L1C_ParteenteraL1C
  parameters:
    PARAM1: 'True'
    PARAM2: samp_rate
  states: {}
- name: Modulos_L1C_ParteenteraL1C_0_0
  id: Modulos_L1C_ParteenteraL1C
  parameters:
    PARAM1: 'False'
    PARAM2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    nconnections: '3'
    size: '256'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulos_L1C_ParteenteraL1C_0, '0', qtgui_time_sink_x_0, '0']
- [Modulos_L1C_ParteenteraL1C_0_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', Modulos_L1C_ParteenteraL1C_0, '0']
- [analog_sig_source_x_0, '0', Modulos_L1C_ParteenteraL1C_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
