options:
  parameters:
    author: Nestor y Andres
    copyright: UIS
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulacion_PM
  states: {}

blocks:
- name: ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    orient: Qt.Horizontal
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: gtx
  id: variable_qtgui_range
  parameters:
    label: ganacia tranmisor
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: coefieciene kp
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: EnvolventecomplejaPML1C_0
  id: EnvolventecomplejaPML1C
  parameters:
    Ac: ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: gtx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventecomplejaPML1C_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaPML1C_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventecomplejaPML1C_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaPML1C_0, '0']

metadata:
  file_format: 1
