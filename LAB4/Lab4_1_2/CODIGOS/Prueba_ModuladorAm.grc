options:
  parameters:
    generate_options: qt_gui
    id: ModuladorAm
    output_language: python
    title: ModuladorAm
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '4'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia Tx
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    orient: Qt.Horizontal
    start: '50'
    step: '0.1'
    stop: '2200'
    value: '50'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicacionesL1C_0
  id: CalculoPotenciaComunicacionesL1C
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuladorAM_L1C_G4_0
  id: ModuladorAM_L1C_G4
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ModuladorAM_L1C_G4_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_L1C_G4_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicacionesL1C_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAM_L1C_G4_0, '0']

metadata:
  file_format: 1
