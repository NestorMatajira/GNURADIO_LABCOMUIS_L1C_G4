options:
  parameters:
    generate_options: qt_gui
    id: PruebaModuladorsDSB_SC
    output_language: python
    title: PruebaModuladorsDSB_SC
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia Tx
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    orient: Qt.Horizontal
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: mode
  id: variable_qtgui_range
  parameters:
    label: Modo
    orient: Qt.Horizontal
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: CalculoPotenciaComunicacionesL1C_0
  id: CalculoPotenciaComunicacionesL1C
  parameters:
    l_vect: '1024'
  states: {}
- name: Envolvente_compleja_DSB_SC_0
  id: Envolvente_compleja_DSB_SC
  parameters:
    Ac: Ac
    K: mode
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [Envolvente_compleja_DSB_SC_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_compleja_DSB_SC_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicacionesL1C_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_compleja_DSB_SC_0, '0']

metadata:
  file_format: 1
